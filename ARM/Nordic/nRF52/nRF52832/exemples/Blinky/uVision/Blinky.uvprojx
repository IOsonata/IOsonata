# Keil uVision project Blinky.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: NRF52832_XXAA
  c include: ..\src;..\..\..\lib\include;..\..\..\..\..\include;..\..\..\..\..\..\include;..\..\..\..\..\..\..\include;..\..\..\..\..\..\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../src/: board.h
    ../../../../../../../exemples/misc/: blinky.c
    ../../../lib/uVision/Debug/: IOsonata_nRF52832.lib
