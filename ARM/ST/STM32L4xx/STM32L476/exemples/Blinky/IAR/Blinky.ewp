# IAR project Blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __PROGRAM_START; STM32L476xx
  ICCARM.CCIncludePath2: ..\src; ..\..\..\lib\include; ..\..\..\..\include; ..\..\..\..\..\..\include; ..\..\..\..\..\..\..\include; ..\..\..\..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Blinky.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\ldscript\iar_stm32l476xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\lib\IAR\Debug\IOSonata_STM32L476.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __PROGRAM_START; STM32L476xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkAdditionalLibs: ..\..\..\lib\IAR\Release\IOSonata_STM32L476.a
  group src
    ../../../../../../../exemples/misc/: blinky.c
    ../src/: board.h
