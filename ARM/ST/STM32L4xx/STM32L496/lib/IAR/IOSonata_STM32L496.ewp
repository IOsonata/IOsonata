# IAR project IOSonata_STM32L496.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496ZG ST STM32L496ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __PROGRAM_START; STM32L496xx
  ICCARM.CCIncludePath2: ..\include; ..\..\..\include; ..\..\..\..\include; ..\..\..\..\..\include; ..\..\..\..\..\..\include; ..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\external\BSEC\algo\lite_version\inc; ..\..\..\..\..\..\..\external\invn
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __PROGRAM_START; STM32L496xx
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group include
    ../../../../../../include/: base64.h blueio_types.h cfifo.h convutil.h crc.h device bridge.h device.h device_intrf.h diskio.h diskio_flash.h fatfs.h intelhex.h isha1.h isha256.h istddef.h md5.h prbs.h pulse_train.h pwm.h sdcard.h seep.h slip_intrf.h stddev.h sysstatus.h sysstatusdef.h utf8.h utf8cvt.h
  group include/converters
    ../../../../../../include/converters/: adc_device.h adc_ltc2495.h analog_comp.h dac_device.h
  group include/coredev
    ../../../../../../include/coredev/: i2c.h iopincfg.h pdm.h spi.h timer.h uart.h
  group include/imu
    ../../../../../../include/imu/: icm20948_img_dmp3a.h imu.h imu_invn_icm20948.h imu_mpu9250.h mpu9250_dmpkey.h mpu9250_dmpmap.h
  group include/audio
    ../../../../../../include/audio/: buzzer.h
  group include/miscdev
    ../../../../../../include/miscdev/: led.h led_apa102.h ledmx.h ledmxfont.h modem.h tca6424a.h
  group include/sensors
    ../../../../../../include/sensors/: accel_sensor.h ag_bmi160.h agm_icm20948.h agm_invn_icm20948.h agm_lsm9ds1.h agm_mpu9250.h am_lsm303c.h gas_sensor.h gyro_l3gd20h.h gyro_sensor.h humi_sensor.h mag_bmm150.h mag_sensor.h press_sensor.h sensor.h temp_sensor.h tph_bme280.h tph_ms8607.h tph_sensor.h tphg_bme680.h
  group include/sys
    ../../../../../../include/sys/: dirent.h
  group include/usb
    ../../../../../../include/usb/: usb_cdcdef.h usb_def.h usb_hiddef.h usb_hidhost.h usb_mscdef.h
  group src
    ../../../../../../src/crypto/: crypto_softsha256.cpp crypto_p256.cpp crypto_uecc.cpp
    ../../../../../../src/coredev/: uart.cpp
    ../../../../src/: timer_stm32.cpp timer_lptim_stm32.cpp timer_tim_stm32.cpp quadspi_stm32.cpp i2c_stm32.cpp
    ../../../../../../src/: base64.c cfifo.c CppRuntimeOverload.cpp crc.c device.cpp device_intrf.cpp diskio_flash.cpp diskio_impl.cpp intelhex.c isha1.c isha256.c md5.c prbs.c pulse_train.c sbuffer.c sdcard_impl.cpp seep_impl.cpp slip_intrf.cpp stddev.c uart_retarget.c utf8.c utf8cvt.cpp
    ../../../../../src/: ResetEntry.c
    ../../../src/: system_stm32l4xx.c
    ../src/: Vector_STM32L496xx.c
  group src/coredev
    ../../../../../../src/coredev/: i2c.cpp spi.cpp timer.cpp uart.c
    ../../../../src/: iopincfg_stm32.cpp spi_stm32.cpp uart_stm32.cpp dma_stm32.cpp
  group src/imu
    ../../../../../../src/imu/: imu.cpp imu_invn_icm20948.cpp imu_mpu9250.cpp
  group src/audio
    ../../../../../../src/audio/: buzzer.cpp
  group src/miscdev
    ../../../../../../src/miscdev/: led_apa102.cpp led_gpio.cpp led_pwm.cpp ledmx.c ledmxfont.c modem.cpp
  group src/sensors
    ../../../../../../src/sensors/: ag_bmi160.cpp agm_icm20948.cpp agm_invn_icm20948.cpp agm_mpu9250.cpp am_lsm303c.cpp gyro_l3gd20h.cpp mag_bmm150.cpp tph_bme280.cpp tph_ms8607.cpp tphg_bme680.cpp
