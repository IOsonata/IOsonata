# IAR project FlashMemoryDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476QE ST STM32L476QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\include; ..\..\..\lib\include; ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\include; ..\..\..\..\..\..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: FlashMemoryDemo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\ldscript\iar_stm32l496xx_flash.icf
  ILINK.IlinkAdditionalLibs: Z:\swdev\IOsonata\ARM\ST\STM32L4xx\STM32L476\lib\IAR\Debug\IOSonata_STM32L476.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ../src/: board.h
    ../../../../../../../exemples/misc/: flash_memory_demo.cpp
