# Keil uVision project IOsonata_nRF52832.uvprojx, settings and files
target Debug (6120000::V6.12::.\ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IOsonata_nRF52832 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: NRF52832_XXAA, SPRT_BUFFER_SIZE=256
  c include: ..\include;..\..\..\..\include;..\..\..\..\..\include;..\..\..\..\..\CMSIS\Core\Include;..\..\..\..\..\..\include
  group src
    ../src/: system_nrf52832.c Vectors_nRF52832.c
    ../../../../src/: iopincfg_nrfx.c iosonata_dfu_public_key.c ledmxio_nrf5x.c i2c_nrf5x.cpp i2c_spi_nrf5x_irq.cpp pdm_nrfx.cpp spi_nrf5x.cpp temp_nrf5x.cpp timer_hf_nrf5x.cpp timer_lf_nrf5x.cpp uart_nrf5x.cpp
    ../../../../../src/: ResetEntry.c
    ../../../../../../src/: base64.c cfifo.c crc.c intelhex.c isha256.c md5.c prbs.c pulse_train.c sbuffer.c stddev.c uart_retarget.c utf8.c CppRuntimeOverload.cpp device.cpp device_intrf.cpp diskio_flash.cpp diskio_impl.cpp sdcard_impl.cpp seep_impl.cpp slip_intrf.cpp utf8cvt.cpp
    ../../../../../../src/coredev/: uart.c i2c.cpp spi.cpp timer.cpp
    ../../../../../../src/pwrmgnt/: pwrmgnt_as3701.cpp
    ../../../../../../src/converters/: adc_ltc2495.cpp
    ../../../../../../src/imu/: imu.cpp imu_icm20948.cpp imu_invn_icm20948.cpp imu_mpu9250.cpp
    ../../../../../../src/miscdev/: buzzer.cpp led_apa102.cpp led_gpio.cpp led_ncp5623b.cpp led_pwm.cpp ledmx.c ledmxfont.c modem.cpp
    ../../../../../../src/sensors/: a_adxl362.cpp accel_h3lis331dl.cpp accel_sensor.cpp ag_bmi160.cpp agm_icm20948.cpp agm_invn_icm20948.cpp agm_mpu9250.cpp am_fxos8700cq.cpp am_lsm303agr.cpp am_lsm303c.cpp gyro_l3gd20h.cpp gyro_sensor.cpp mag_ak09916.cpp mag_bmm150.cpp mag_sensor.cpp tph_bme280.cpp tph_ms8607.cpp tphg_bme680.cpp
target Release (6120000::V6.12::.\ARMCLANG)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: as above
  output: IOsonata_nRF52832 (library)
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: NRF52832_XXAA, SPRT_BUFFER_SIZE=256
  c include: ..\include;..\..\..\..\include;..\..\..\..\..\include;..\..\..\..\..\CMSIS\Core\Include;..\..\..\..\..\..\include;..\..\..\..\..\..\..\external\BSEC\algo\lite_version\inc;..\..\..\..\..\..\..\external\Invn
