# IAR project IOsonata_nRF52832.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52832_xxAA NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __PROGRAM_START; GATT_PROXY; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; NRF_DFU_TRANSPORT_BLE; NRF_DFU_SETTINGS_VERSION=1; NRF_SD_BLE_API_VERSION=6; SOFTDEVICE_PRESENT; BLE_STACK_SUPPORT_REQD; S132; NRF52832_XXAA; SPRT_BUFFER_SIZE=256; uECC_ENABLE_VLI_API; uECC_VLI_NATIVE_LITTLE_ENDIAN=1; uECC_SQUARE_FUNC=1; uECC_SUPPORTS_secp256r1=1; uECC_SUPPORT_COMPRESSED_POINT=0; uECC_OPTIMIZATION_LEVEL=3; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_58; NRF52_PAN_55; NRF52_PAN_54; NRF52_PAN_31; NRF52_PAN_30; NRF52_PAN_51; NRF52_PAN_36; NRF52_PAN_53; NRF52_PAN_20; NRF52_PAN_64; NRF52_PAN_62; NRF52_PAN_63; NRF52_PAN_74; CONFIG_GPIO_AS_PINRESET
  ICCARM.CCIncludePath2: ..\include; ..\..\..\..\include; ..\..\..\..\..\include; ..\..\..\..\..\..\include; ..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\external\invn; ..\..\..\..\..\..\..\external\BSEC\algo; ../../../../../../micro-ecc; ../../../../../../../external/nRF5_SDK/external/mbedtls/include; ../../../../../../../external\nRF5_SDK/modules/nrfx/hal; ../../../../../../../external\nRF5_SDK/modules/nrfx/mdk; ../../../../../../../external\nRF5_SDK/modules/nrfx/drivers/include; ../../../../../../../external\nRF5_SDK/modules/nrfx; ../../../../../../../external\nRF5_SDK/integration/nrfx; ../../../../../../../external\nRF5_SDK/integration/nrfx/legacy; ../../../../../../../external/nRF5_SDK/components/libraries/stack_info; ../../../../../../../external/nRF5_SDK/components/libraries/atomic; ../../../../../../../external/nRF5_SDK/components/libraries/atomic_flags; ../../../../../../../external/nRF5_SDK/components/libraries/balloc; ../../../../../../../external/nRF5_SDK/components/libraries/queue; ../../../../../../../external/nRF5_SDK/components/libraries/sha256; ../../../../../../../external/nRF5_SDK/components/libraries/crypto; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/cifra; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/optiga; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/oberon; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/mbedtls; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/micro_ecc; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/cc310; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/cc310_bl; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/nrf_hw; ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/nrf_sw; ../../../../../../../external/nRF5_SDK/components/libraries/memobj; ../../../../../../../external/nRF5_SDK/components/libraries/cli; ../../../../../../../external/nRF5_SDK/components/libraries/log; ../../../../../../../external/nRF5_SDK/components/libraries/log/src; ../../../../../../../external/nRF5_SDK/components/libraries/scheduler; ../../../../../../../external/nRF5_SDK/components/libraries/mutex; ../../../../../../../external/nRF5_SDK/components/libraries/timer; ../../../../../../../external/nRF5_SDK/components/libraries/fstorage; ../../../../../../../external/nRF5_SDK/components/libraries/fds; ../../../../../../../external/nRF5_SDK/components/libraries/atomic_fifo; ../../../../../../../external/nRF5_SDK/components/libraries/strerror; ../../../../../../../external/nRF5_SDK/components/libraries/util; ../../../../../../../external/nRF5_SDK/components/libraries/delay; ../../../../../../../external/nRF5_SDK/components/libraries/pwr_mgmt; ../../../../../../../external/nRF5_SDK/components/libraries/crc32; ../../../../../../../external/nRF5_SDK/components/libraries/mem_manager; ../../../../../../../external/nRF5_SDK/components/libraries/bootloader/ble_dfu; ../../../../../../../external/nRF5_SDK/components/libraries/bootloader/dfu; ../../../../../../../external/nRF5_SDK/components/libraries/bootloader; ../../../../../../../external/nRF5_SDK/components/libraries/experimental_section_vars; ../../../../../../../external/nRF5_SDK/components/libraries/svc; ../../../../../../../external/nRF5_SDK/components/ble/nrf_ble_gatt; ../../../../../../../external/nRF5_SDK/components/ble/peer_manager; ../../../../../../../external\nRF5_SDK\components\ble\ble_advertising; ../../../../../../../external/nRF5_SDK/components/ble/nrf_ble_scan; ../../../../../../../external/nRF5_SDK/components/ble/common; ../../../../../../../external/nRF5_SDK/components/ble/ble_services/ble_dis; ../../../../../../../external/nRF5_SDK/components/ble/ble_services/ble_bas; ../../../../../../../external/nRF5_SDK/components/proprietary_rf/esb; ../../../../../../../external/nRF5_SDK/components/softdevice/s132/headers; ../../../../../../../external/nRF5_SDK/components/softdevice/common; ../../../../../../../external/nRF5_SDK/components/softdevice/mbr/nrf52832/headers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: IOsonata_nRF52832.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group include
    ../../../../../../include/: base64.h blueio_types.h cfifo.h convutil.h crc.h device bridge.h device.h device_intrf.h diskio.h diskio_flash.h fatfs.h intelhex.h isha1.h isha256.h istddef.h md5.h prbs.h pulse_train.h pwm.h sdcard.h seep.h slip_intrf.h stddev.h sysstatus.h sysstatusdef.h utf8.h utf8cvt.h
  group include/bluetooth
    ../../../../../../include/bluetooth/: bleadv_mandata.h blueio_blesrvc.h
  group include/converters
    ../../../../../../include/converters/: adc_device.h adc_ltc2495.h analog_comp.h dac_device.h
  group include/coredev
    ../../../../../../include/coredev/: i2c.h iopincfg.h pdm.h spi.h timer.h uart.h
  group include/imu
    ../../../../../../include/imu/: icm20948_img_dmp3a.h imu.h imu_invn_icm20948.h imu_mpu9250.h mpu9250_dmpkey.h mpu9250_dmpmap.h
  group include/audio
    ../../../../../../include/audio/: buzzer.h
  group include/miscdev
    ../../../../../../include/miscdev/: led.h led_apa102.h ledmx.h ledmxfont.h modem.h tca6424a.h
  group include/pwrmgnt
    ../../../../../../include/pwrmgnt/: pwrmgnt.h pwrmgnt_as3701.h
  group include/sensors
    ../../../../../../include/sensors/: a_adxl362.h accel_sensor.h ag_bmi160.h agm_icm20948.h agm_invn_icm20948.h agm_lsm9ds1.h agm_mpu9250.h am_lsm303c.h gas_sensor.h gyro_l3gd20h.h gyro_sensor.h humi_sensor.h mag_sensor.h press_sensor.h sensor.h temp_sensor.h tph_bme280.h tph_ms8607.h tph_sensor.h tphg_bme680.h
  group include/sys
    ../../../../../../include/sys/: dirent.h
  group src
    ../../../src/: adc_nrf52_saadc.cpp nrf_sdh.c nrf_sdh_soc.c
    ../../../../../../src/: base64.c cfifo.c CppRuntimeOverload.cpp crc.c device.cpp device_intrf.cpp diskio_flash.cpp diskio_impl.cpp intelhex.c isha1.c isha256.c md5.c prbs.c pulse_train.c sbuffer.c sdcard_impl.cpp seep_impl.cpp slip_intrf.cpp stddev.c uart_retarget.c utf8.c utf8cvt.cpp
    ../../../../src/: esb_intrf.cpp iosonata_dfu_public_key.c ledmxio_nrf5x.c temp_nrf5x.cpp
    ../../../../../src/: ResetEntry.c
    ../src/: system_nrf52832.c Vectors_nRF52832.c
  group src/bluetooth
    ../../../../src/: ble_app_handler.c ble_dev.cpp ble_intrf.cpp ble_service.cpp blueio_blesrvc.cpp uart_bleintrf.cpp
    ../../../src/: ble_app_nrf52.cpp
  group src/converters
    ../../../../../../src/converters/: adc_ltc2495.cpp
    ../../../../src/: analog_comp_nrf5x.cpp
  group src/coredev
    ../../../../../../src/coredev/: i2c.cpp spi.cpp timer.cpp uart.c
    ../../../../src/: i2c_nrf5x.cpp i2c_spi_nrf5x_irq.cpp iopincfg_nrfx.c pdm_nrfx.cpp spi_nrf5x.cpp timer_hf_nrf5x.cpp timer_lf_nrf5x.cpp uart_nrf5x.cpp
    ../../../src/: pwm_nrf52.cpp
  group src/imu
    ../../../../../../src/imu/: imu.cpp imu_invn_icm20948.cpp imu_mpu9250.cpp
  group src/audio
    ../../../../../../src/audio/: buzzer.cpp
  group src/miscdev
    ../../../../../../src/miscdev/: led_apa102.cpp led_gpio.cpp led_pwm.cpp ledmx.c ledmxfont.c modem.cpp
  group src/nRF5_SDK/ble
    ../../../../../../../external/nRF5_SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../external/nRF5_SDK/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../external/nRF5_SDK/components/ble/ble_dtm/: ble_dtm.c
    ../../../../../../../external/nRF5_SDK/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../../../../external/nRF5_SDK/components/ble/ble_racp/: ble_racp.c
    ../../../../../../../external/nRF5_SDK/components/ble/ble_radio_notification/: ble_radio_notification.c
    ../../../../../../../external/nRF5_SDK/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../../../../external/nRF5_SDK/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../../../../../../external/nRF5_SDK/components/ble/nrf_ble_scan/: nrf_ble_scan.c
  group src/nRF5_SDK/ble/ble_services
    ../../../../../../../external/nRF5_SDK/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../external/nRF5_SDK/components/ble/ble_services/ble_dis/: ble_dis.c
  group src/nRF5_SDK/ble/peer_manager
    ../../../../../../../external/nRF5_SDK/components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_lesc.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
  group src/nRF5_SDK/libraries
    ../../../../../../../external/nRF5_SDK/components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../../../../../../external/nRF5_SDK/components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../external/nRF5_SDK/components/libraries/timer/: app_timer.c
    ../../../../../../../external/nRF5_SDK/components/libraries/ecc/: ecc.c
    ../../../../../../../external/nRF5_SDK/components/libraries/fds/: fds.c
    ../../../../../../../external/nRF5_SDK/components/libraries/hardfault/nrf52/handler/: hardfault_handler_iar.c
    ../../../../../../../external/nRF5_SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/mbedtls/: mbedtls_backend_aes.c mbedtls_backend_aes_aead.c mbedtls_backend_ecc.c mbedtls_backend_ecdh.c mbedtls_backend_ecdsa.c mbedtls_backend_hash.c mbedtls_backend_hmac.c mbedtls_backend_init.c
    ../../../../../../../external/nRF5_SDK/components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
    ../../../../../../../external/nRF5_SDK/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../../../external/nRF5_SDK/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../../../../external/nRF5_SDK/components/libraries/atomic/: nrf_atomic.c
    ../../../../../../../external/nRF5_SDK/components/libraries/balloc/: nrf_balloc.c
    ../../../../../../../external/nRF5_SDK/components/libraries/crypto/: nrf_crypto_aead.c nrf_crypto_aes.c nrf_crypto_aes_shared.c nrf_crypto_ecc.c nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_eddsa.c nrf_crypto_error.c nrf_crypto_hash.c nrf_crypto_hkdf.c nrf_crypto_hmac.c nrf_crypto_init.c nrf_crypto_rng.c nrf_crypto_shared.c
    ../../../../../../../external/nRF5_SDK/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../../../external/nRF5_SDK/components/libraries/crypto/backend/nrf_hw/: nrf_hw_backend_init.c nrf_hw_backend_rng.c nrf_hw_backend_rng_mbedtls.c
    ../../../../../../../external/nRF5_SDK/components/libraries/memobj/: nrf_memobj.c
    ../../../../../../../external/nRF5_SDK/components/libraries/queue/: nrf_queue.c
    ../../../../../../../external/nRF5_SDK/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../../../external/nRF5_SDK/components/libraries/sha256/: sha256.c
  group src/nRF5_SDK/nrfx/drivers/src
    ../../../../../../../external/nRF5_SDK/modules/nrfx/drivers/src/: nrfx_rng.c
  group src/nRF5_SDK/nrfx/legacy
    ../../../../../../../external/nRF5_SDK/integration/nrfx/legacy/: nrf_drv_rng.c
  group src/nRF5_SDK/proprietary_rf/esb
    ../../../../../../../external/nRF5_SDK/components/proprietary_rf/esb/: nrf_esb.c
  group src/nRF5_SDK/softdevice/common
    ../../../../../../../external/nRF5_SDK/components/softdevice/common/: nrf_sdh_ble.c
  group src/pwrmgnt
    ../../../../../../src/pwrmgnt/: pwrmgnt_as3701.cpp
  group src/sensors
    ../../../../../../src/sensors/: a_adxl362.cpp ag_bmi160.cpp agm_icm20948.cpp agm_invn_icm20948.cpp agm_mpu9250.cpp am_lsm303c.cpp gyro_l3gd20h.cpp tph_bme280.cpp tph_ms8607.cpp tphg_bme680.cpp
