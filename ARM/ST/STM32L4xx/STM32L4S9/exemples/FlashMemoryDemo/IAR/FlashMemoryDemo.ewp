# IAR project FlashMemoryDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4S9AI ST STM32L4S9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S9xx
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\include; ..\..\..\lib\include; ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\include; ..\..\..\..\..\..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: FlashMemoryDemo.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\ldscript\iar_stm32l4s9xx_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../lib/IAR/Debug/IOSonata_STM32L4S9.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32L4S9xx
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../lib/IAR/Release/IOSonata_STM32L4S9.a
  group (top)
    ../src/: board.h
    ../../../../../../../exemples/misc/: flash_memory_demo.cpp
